# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F750N8 ST STM32F750N8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F750xx; STM32F7XX; DRAWING_DMA2D_BPP=16; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__
  ICCARM.CCIncludePath2: ..\comm\inc; ..\config\inc; ..\core\inc; ..\fs\inc; ..\hal\inc; ..\main\inc; ..\net\inc; platform\inc; platform\inc\intern; ..\ssl\inc; ..\thirdparty\systemview\inc; ..\thirdparty\systemview-freertos\inc; ..\thirdparty\libwebp; ..\thirdparty\libwebp\src\dec; ..\thirdparty\libwebp\src\dsp; ..\thirdparty\libwebp\src\enc; ..\thirdparty\libwebp\src\microej; ..\thirdparty\libwebp\src\utils; ..\thirdparty\libwebp\src\webp; ..\trace\inc; ..\ui\inc; ..\util\inc; ..\watchdog\inc; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\Components\Common; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\STM32F7508-Discovery; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Core\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Include; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FatFs\src; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include\compat\posix; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\system; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\mbedTLS\include; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\config\inc; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\include
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: STM32F750N8Hx_FLASH.icf
  ILINK.IlinkExtraOptions: --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F750xx; STM32F7XX; DRAWING_DMA2D_BPP=16; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__
  ICCARM.CCIncludePath2: ..\comm\inc; ..\config\inc; ..\core\inc; ..\fs\inc; ..\hal\inc; ..\main\inc; ..\net\inc; platform\inc; ..\ssl\inc; ..\thirdparty\systemview\inc; ..\thirdparty\systemview-freertos\inc; ..\thirdparty\libwebp; ..\thirdparty\libwebp\src\dec; ..\thirdparty\libwebp\src\dsp; ..\thirdparty\libwebp\src\enc; ..\thirdparty\libwebp\src\microej; ..\thirdparty\libwebp\src\utils; ..\thirdparty\libwebp\src\webp; ..\trace\inc; ..\ui\inc; ..\util\inc; ..\watchdog\inc; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\Components\Common; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\STM32F7508-Discovery; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Core\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Include; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FatFs\src; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include\compat\posix; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\system; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\mbedTLS\include; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy
configuration Iperf (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F750xx; STM32F7XX; DRAWING_DMA2D_BPP=16; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__; IPERF_BUILD
  ICCARM.CCIncludePath2: ..\validation\iperf\inc; ..\comm\inc; ..\config\inc; ..\core\inc; ..\main\inc; ..\net\inc; ..\ssl\inc; ..\thirdparty\systemview\inc; ..\thirdparty\systemview-freertos\inc; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\Components\Common; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\STM32F7508-Discovery; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Core\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Include; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FatFs\src; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include\compat\posix; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\system; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\mbedTLS\include; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy
  ILINK.IlinkIcfFile: STM32F750N8Hx_FLASH_iperf.icf
configuration Unit_test (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F750xx; USE_HAL_DRIVER; USE_STM32F7508_DISCO; MBEDTLS_CONFIG_FILE="mbedtls_config.h"; IAR_IDE; __VFP_FP__; __ICCARM__; ITERATIONS=40000; VALIDATION_BUILD
  ICCARM.CCIncludePath2: ..\comm\inc; ..\config\inc; ..\core\inc; ..\fs\inc; ..\hal\inc; ..\main\inc; ..\net\inc; platform\inc; ..\ssl\inc; ..\thirdparty\systemview\inc; ..\thirdparty\systemview-freertos\inc; ..\thirdparty\libwebp; ..\thirdparty\libwebp\src\dec; ..\thirdparty\libwebp\src\dsp; ..\thirdparty\libwebp\src\enc; ..\thirdparty\libwebp\src\microej; ..\thirdparty\libwebp\src\utils; ..\thirdparty\libwebp\src\webp; ..\trace\inc; ..\ui\inc; ..\util\inc; ..\validation\framework\c\CoreMark; ..\validation\tests\core\c\inc; ..\validation\port\inc; ..\validation\framework\c\embunit\embUnit; ..\validation\framework\c\embunit\textui; ..\validation\framework\c\utils\inc; ..\watchdog\inc; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\Components\Common; ..\..\..\sdk\STM32CubeF7\Drivers\BSP\STM32F7508-Discovery; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Core\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\sdk\STM32CubeF7\Drivers\CMSIS\Include; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FatFs\src; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\src\include\compat\posix; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\LwIP\system; ..\..\..\sdk\STM32CubeF7\Middlewares\Third_Party\mbedTLS\include; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\sdk\STM32CubeF7\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc; ..\..\..\sdk\STM32CubeF7\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy
  ILINK.IlinkIcfFile: STM32F750N8Hx_FLASH_validation.icf
  group microej/comm/inc
    ../comm/inc/: LLCOMM_CDC.h LLCOMM_CDC_configuration.h LLCOMM_UART.h LLCOMM_UART_configuration.h
  group microej/comm/src
    ../comm/src/: comms.c LLCOMM_CDC.c LLCOMM_UART.c
  group microej/config/inc
    ../config/inc/: ffconf.h FreeRTOSConfig.h lwipopts.h mbedtls_config.h stm32f7xx_hal_conf.h usbh_conf.h watchdog_config.h
  group microej/config/src
    ../config/src/: usbh_conf.c
  group microej/core/inc
    ../core/inc/: bsp_util.h cpuload.h cpuload_conf.h cpuload_impl.h device.h fault_handlers.h interrupts.h microej.h microej_main.h microej_time.h
  group microej/core/src
    ../core/src/: cpuload.c cpuload_impl_FreeRTOS.c fault_handlers.c hooks_FreeRTOS.c interrupts.c LLBSP_generic.c LLDEVICE.c LLMJVM_FreeRTOS.c microej_main.c microej_time.c putchar.c SEGGER_SYSVIEW_Config_MicroEJ_FreeRTOS.c
  group microej/fs/inc
    ../fs/inc/: fs_configuration.h fs_helper.h sd_diskio_dma_rtos.h
  group microej/fs/src
    ../fs/src/: fs_helper_FatFs.c LLFS_File_impl.c LLFS_impl.c LLFS_STM32_init_sdcard.c sd_diskio_dma_rtos.c
  group microej/hal/inc
    ../hal/inc/: adc_manager.h adc_manager_impl.h dac_manager.h dac_manager_impl.h hal_stm32.h hal_stm32_configuration.h
  group microej/hal/src
    ../hal/src/: adc_manager.c dac_manager.c hal_stm32f7508disco.c LLHAL_GPIO.c
  group microej/kf/src
    ../kf/src/: LLKERNEL_SDRAM.c
  group microej/main/inc
    ../main/inc/: main.h memory.h memory_msp.h stm32f7xx_it.h
  group microej/main/src
    ../main/src/: fmc.c main.c memory_msp.c qspi.c stm32f7xx_custom.c stm32f7xx_it.c system_stm32f7xx.c
  group microej/net/inc
    ../net/inc/: async_select.h async_select_cache.h async_select_configuration.h ethernetif.h LLNET_Common.h LLNET_configuration.h LLNET_NETWORK_MEM.h lwip_util.h MicroEJ_errno.h
  group microej/net/inc/sys
    ../net/inc/sys/: time.h
  group microej/net/src
    ../net/src/: async_select.c async_select_cache.c async_select_osal.c ethernetif.c LLNET_CHANNEL_bsd.c LLNET_Common.c LLNET_DATAGRAMSOCKETCHANNEL_bsd.c LLNET_DNS_native_impl.c LLNET_DNS_soft_impl.c LLNET_MULTICASTSOCKETCHANNEL_bsd.c LLNET_NETWORK_MEM.c LLNET_NETWORKADDRESS_bsd.c LLNET_NETWORKINTERFACE_lwip.c LLNET_SOCKETCHANNEL_bsd.c LLNET_STREAMSOCKETCHANNEL_bsd.c lwip_util.c
  group microej/platform/inc
    ../platform/inc/: BESTFIT_ALLOCATOR.h BESTFIT_ALLOCATOR_impl.h dw_drawing.h dw_drawing_soft.h LLBSP_impl.h LLCOMM.h LLCOMM_BUFFERED_CONNECTION.h LLCOMM_BUFFERED_CONNECTION_impl.h LLCOMM_CONNECTION.h LLCOMM_CUSTOM_CONNECTION.h LLCOMM_CUSTOM_CONNECTION_impl.h LLCOMM_impl.h LLDEVICE_impl.h LLDW_PAINTER_impl.h LLFS_File_impl.h LLFS_impl.h LLHAL_GPIO_impl.h LLMJVM.h LLMJVM_impl.h LLMJVM_MONITOR_impl.h LLNET_CHANNEL_impl.h LLNET_CONF.h LLNET_CONSTANTS.h LLNET_DATAGRAMSOCKETCHANNEL_impl.h LLNET_DNS_impl.h LLNET_ERRORS.h LLNET_MULTICASTSOCKETCHANNEL_impl.h LLNET_NETWORKADDRESS_impl.h LLNET_NETWORKINTERFACE_impl.h LLNET_SOCKETCHANNEL_impl.h LLNET_SSL_CONSTANTS.h LLNET_SSL_CONTEXT_impl.h LLNET_SSL_ERRORS.h LLNET_SSL_SOCKET_impl.h LLNET_STREAMSOCKETCHANNEL_impl.h LLSEC_CIPHER_impl.h LLSEC_CONSTANTS.h LLSEC_DIGEST_impl.h LLSEC_ERRORS.h LLSEC_KEY_FACTORY_impl.h LLSEC_MAC_impl.h LLSEC_RANDOM_impl.h LLSEC_SIG_impl.h LLSEC_X509_CERT_impl.h LLSP_impl.h LLTRACE_impl.h LLUI_DISPLAY.h LLUI_DISPLAY_impl.h LLUI_INPUT.h LLUI_INPUT_impl.h LLUI_LED_impl.h LLUI_PAINTER_impl.h microui_constants.h MJVM_MONITOR.h MJVM_MONITOR_types.h sni.h sp.h trace.h ui_drawing.h ui_drawing_soft.h
  group microej/platform/inc/intern
    ../platform/inc/intern/: BESTFIT_ALLOCATOR.h BESTFIT_ALLOCATOR_impl.h LLBSP_impl.h LLCOMM.h LLCOMM_BUFFERED_CONNECTION.h LLCOMM_BUFFERED_CONNECTION_impl.h LLCOMM_CONNECTION.h LLCOMM_CUSTOM_CONNECTION.h LLCOMM_CUSTOM_CONNECTION_impl.h LLCOMM_impl.h LLDEVICE_impl.h LLFS_File_impl.h LLFS_impl.h LLHAL_GPIO_impl.h LLMJVM.h LLMJVM_impl.h LLNET_CHANNEL_impl.h LLNET_CONF.h LLNET_DATAGRAMSOCKETCHANNEL_impl.h LLNET_DNS_impl.h LLNET_MULTICASTSOCKETCHANNEL_impl.h LLNET_NETWORKADDRESS_impl.h LLNET_NETWORKINTERFACE_impl.h LLNET_SOCKETCHANNEL_impl.h LLNET_SSL_CONTEXT_impl.h LLNET_SSL_SOCKET_impl.h LLNET_STREAMSOCKETCHANNEL_impl.h LLSEC_CIPHER_impl.h LLSEC_DIGEST_impl.h LLSEC_KEY_FACTORY_impl.h LLSEC_MAC_impl.h LLSEC_RANDOM_impl.h LLSEC_SIG_impl.h LLSEC_X509_CERT_impl.h LLSP_impl.h trace_intern.h
  group microej/platform/lib
    platform/lib/: ecom-comm.a microejapp.o microejruntime.a
  group microej/security/src
    ../security/src/: LLSEC_RANDOM_impl.c LLSEC_X509_CERT_mbedtls.c
  group microej/ssl/inc
    ../ssl/inc/: LLNET_SSL_utils_mbedtls.h LLNET_SSL_verifyCallback.h net_ssl_errors.h ssl_parse.h ssl_utils.h
  group microej/ssl/src
    ../ssl/src/: LLNET_SSL_CONTEXT_impl.c LLNET_SSL_SOCKET_impl.c LLNET_SSL_utils_mbedtls.c LLNET_SSL_verifyCallback.c net_ssl_errors.c ssl_parse.c ssl_utils.c
  group microej/thirdparty/libwebp/src/dec
    ../thirdparty/libwebp/src/dec/: alpha_dec.c alphai_dec.h buffer_dec.c common_dec.h frame_dec.c idec_dec.c io_dec.c quant_dec.c tree_dec.c vp8_dec.c vp8_dec.h vp8i_dec.h vp8l_dec.c vp8li_dec.h webp_dec.c webpi_dec.h
  group microej/thirdparty/libwebp/src/dsp
    ../thirdparty/libwebp/src/dsp/: alpha_processing.c cost.c cpu.c dec.c dec_clip_tables.c dsp.h enc.c filters.c lossless.c lossless.h lossless_common.h lossless_enc.c quant.h rescaler.c ssim.c upsampling.c yuv.c yuv.h
  group microej/thirdparty/libwebp/src/microej
    ../thirdparty/libwebp/src/microej/: microej_decode.c microej_decode.h microej_utils.c
  group microej/thirdparty/libwebp/src/utils
    ../thirdparty/libwebp/src/utils/: bit_reader_inl_utils.h bit_reader_utils.c bit_reader_utils.h bit_writer_utils.c bit_writer_utils.h color_cache_utils.c color_cache_utils.h endian_inl_utils.h filters_utils.c filters_utils.h huffman_encode_utils.c huffman_encode_utils.h huffman_utils.c huffman_utils.h quant_levels_dec_utils.c quant_levels_dec_utils.h quant_levels_utils.c quant_levels_utils.h random_utils.c random_utils.h rescaler_utils.c rescaler_utils.h thread_utils.c thread_utils.h utils.c utils.h
  group microej/thirdparty/libwebp/src/webp
    ../thirdparty/libwebp/src/webp/: decode.h demux.h encode.h format_constants.h mux.h mux_types.h types.h
  group microej/thirdparty/systemview/inc
    ../thirdparty/systemview/inc/: Global.h SEGGER.h SEGGER_RTT.h SEGGER_RTT_configuration.h SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_configuration.h SEGGER_SYSVIEW_Int.h
  group microej/thirdparty/systemview/src
    ../thirdparty/systemview/src/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group microej/thirdparty/systemview-freertos/inc
    ../thirdparty/systemview-freertos/inc/: SEGGER_SYSVIEW_FreeRTOS.h
  group microej/thirdparty/systemview-freertos/src
    ../thirdparty/systemview-freertos/src/: SEGGER_SYSVIEW_FreeRTOS.c
  group microej/trace/inc
    ../trace/inc/: LLMJVM_MONITOR_sysview.h LLTRACE_sysview_configuration.h
  group microej/trace/src
    ../trace/src/: LLMJVM_MONITOR_sysview.c LLTRACE_sysview.c
  group microej/ui/inc
    ../ui/inc/: buttons_helper.h buttons_helper_configuration.h buttons_manager.h drawing_dma2d.h event_generator.h framerate.h framerate_conf.h framerate_impl.h io_task.h LLDISPLAY_configuration.h touch_helper.h touch_helper_configuration.h touch_manager.h
  group microej/ui/src
    ../ui/src/: buttons_helper.c buttons_manager.c event_generator.c framerate.c framerate_impl_FreeRTOS.c grayscale.c io_task.c LLDW_PAINTER_impl.c LLUI_DISPLAY.c LLUI_INPUT.c LLUI_LED.c LLUI_PAINTER_impl.c touch_helper.c touch_manager.c ui_drawing.c ui_drawing_dma2d.c ui_drawing_stub.c ui_image_drawing.c
  group microej/util/inc
    ../util/inc/: microej_async_worker.h microej_pool.h osal.h osal_portmacro.h
  group microej/util/src
    ../util/src/: microej_async_worker.c microej_pool.c osal_FreeRTOS.c
  group microej/validation/framework/c/CoreMark
    ../validation/framework/c/CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
  group microej/validation/framework/c/embunit/embUnit
    ../validation/framework/c/embunit/embUnit/: AssertImpl.c AssertImpl.h config.h embUnit.h HelperMacro.h RepeatedTest.c RepeatedTest.h stdImpl.c stdImpl.h Test.h TestCaller.c TestCaller.h TestCase.c TestCase.h TestListener.h TestResult.c TestResult.h TestRunner.c TestRunner.h TestSuite.c TestSuite.h
  group microej/validation/framework/c/utils/inc
    ../validation/framework/c/utils/inc/: bsp_util.h u_print.h u_time_base.h
  group microej/validation/framework/c/utils/src
    ../validation/framework/c/utils/src/: u_print.c
  group microej/validation/iperf/inc
    ../validation/iperf/inc/: iperf.h iperf_configuration.h LLNET_CONF.h sni.h
  group microej/validation/iperf/src
    ../validation/iperf/src/: iperf_main.c LLNET_NETWORK_MEM.c
  group microej/validation/port/inc
    ../validation/port/inc/: core_portme.h
  group microej/validation/port/src
    ../validation/port/src/: core_benchmark.c core_portme.c ram_checks.c time_base.c
  group microej/validation/tests/core/c/inc
    ../validation/tests/core/c/inc/: t_core_core_benchmark.h t_core_main.h t_core_print.h t_core_ram.h t_core_time_base.h x_core_benchmark.h x_ram_checks.h x_ram_speed.h x_version.h
  group microej/validation/tests/core/c/src
    ../validation/tests/core/c/src/: t_core_core_benchmark.c t_core_main.c t_core_print.c t_core_ram.c t_core_time_base.c x_impl_ram_checks.c x_impl_ram_speed.c x_ram_checks.c x_ram_speed.c
  group microej/watchdog/inc
    ../watchdog/inc/: timer_msp.h watchdog.h
  group microej/watchdog/src
    ../watchdog/src/: timer_msp.c watchdog.c
  group sdk/STM32CubeF7/Drivers/BSP/Components/ft5336
    ../../../sdk/STM32CubeF7/Drivers/BSP/Components/ft5336/: ft5336.c ft5336.h
  group sdk/STM32CubeF7/Drivers/BSP/STM32F7508-Discovery
    ../../../sdk/STM32CubeF7/Drivers/BSP/STM32F7508-Discovery/: stm32f7508_discovery.c stm32f7508_discovery.h stm32f7508_discovery_audio.c stm32f7508_discovery_audio.h stm32f7508_discovery_camera.c stm32f7508_discovery_camera.h stm32f7508_discovery_eeprom.c stm32f7508_discovery_eeprom.h stm32f7508_discovery_lcd.c stm32f7508_discovery_lcd.h stm32f7508_discovery_sd.c stm32f7508_discovery_sd.h stm32f7508_discovery_sdram.c stm32f7508_discovery_sdram.h stm32f7508_discovery_ts.c stm32f7508_discovery_ts.h
  group sdk/STM32CubeF7/Drivers/CMSIS/Core/Include
    ../../../sdk/STM32CubeF7/Drivers/CMSIS/Core/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdk/STM32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Include
    ../../../sdk/STM32CubeF7/Drivers/CMSIS/Device/ST/STM32F7xx/Include/: stm32f750xx.h stm32f7xx.h system_stm32f7xx.h
  group sdk/STM32CubeF7/Drivers/CMSIS/Include
    ../../../sdk/STM32CubeF7/Drivers/CMSIS/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc
    ../../../sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_exti.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_mmc.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_smbus.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_spi_ex.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_adc.h stm32f7xx_ll_bus.h stm32f7xx_ll_cortex.h stm32f7xx_ll_crc.h stm32f7xx_ll_dac.h stm32f7xx_ll_dma.h stm32f7xx_ll_dma2d.h stm32f7xx_ll_exti.h stm32f7xx_ll_fmc.h stm32f7xx_ll_gpio.h stm32f7xx_ll_i2c.h stm32f7xx_ll_iwdg.h stm32f7xx_ll_lptim.h stm32f7xx_ll_pwr.h stm32f7xx_ll_rcc.h stm32f7xx_ll_rng.h stm32f7xx_ll_rtc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_spi.h stm32f7xx_ll_system.h stm32f7xx_ll_tim.h stm32f7xx_ll_usart.h stm32f7xx_ll_usb.h stm32f7xx_ll_utils.h stm32f7xx_ll_wwdg.h
  group sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy
    ../../../sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h stm32f7xx_hal_can_legacy.h stm32f7xx_hal_eth_legacy.h
  group sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src
    ../../../sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src/Legacy
    ../../../sdk/STM32CubeF7/Drivers/STM32F7xx_HAL_Driver/Src/Legacy/: stm32f7xx_hal_eth.c
  group sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc
    ../../../sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc/: usbh_cdc.h
  group sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src
    ../../../sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Core/Inc
    ../../../sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_ctlreq.h usbh_def.h usbh_ioreq.h usbh_pipes.h
  group sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Core/Src
    ../../../sdk/STM32CubeF7/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/FatFs/src
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h integer.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/FatFs/src/option
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/include
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/api
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/apps/lwiperf
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/apps/lwiperf/: lwiperf.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/core
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/core/ipv4
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/core/ipv6
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/: netdb.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa/: inet.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/net
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/net/: if.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/sys
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/posix/sys/: socket.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/stdc
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/compat/stdc/: errno.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/apps
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/apps/: lwiperf.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/priv
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/prot
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/netif
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/netif
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/system/arch
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/system/arch/: bpstruct.h cc.h cpu.h epstruct.h init.h lib.h perf.h sys_arch.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/system/OS
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group sdk/STM32CubeF7/Middlewares/Third_Party/mbedTLS/include/mbedtls
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/mbedTLS/include/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h chacha20.h chachapoly.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hkdf.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h nist_kw.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h poly1305.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group sdk/STM32CubeF7/Middlewares/Third_Party/mbedTLS/library
    ../../../sdk/STM32CubeF7/Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group startup
    ./: startup_stm32f750xx.s
